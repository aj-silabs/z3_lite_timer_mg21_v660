# IAR project z3_lite_timer_mg21_v660.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG21A010F1024IM32 SiliconLaboratories EFR32MG21A010F1024IM32
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: LOCAL_STORAGE_BTL; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; EFR32_SERIES2_CONFIG1_MICRO; EFR32MG21; EFR32MG21A010F1024IM32; ATTRIBUTE_STORAGE_CONFIGURATION="z3_lite_timer_mg21_v660_endpoint_config.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="z3_lite_timer_mg21_v660_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="z3_lite_timer_mg21_v660.h"; __SOURCEFILE__="$FILE_FNAME$"; PSSTORE_SIZE=0; LONGTOKEN_SIZE=0; LOCKBITS_IN_MAINFLASH_SIZE=8192; HAL_CONFIG=1; EMBER_AF_USE_HWCONF; LED_BLINK_PERIOD_MS=1000; NO_LED=1; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_STACK_ZIGBEE; MBEDTLS_CONFIG_FILE="mbedtls-config-generated.h"; USE_NVM3; NVM3_DEFAULT_NVM_SIZE=NVM3_FLASH_PAGES*FLASH_PAGE_SIZE; EMLIB_USER_CONFIG; HAL_BULBPWM_ENABLE=1; HAL_BULBPWM_FREQUENCY=1000; APPLICATION_TOKEN_HEADER="znet-token.h"; APPLICATION_MFG_TOKEN_HEADER="znet-mfg-token.h"; MBEDTLS_DEVICE_ACCELERATION_CONFIG_FILE="configs/config-device-acceleration.h"; MBEDTLS_DEVICE_ACCELERATION_CONFIG_APP_FILE="config-device-acceleration-app.h"; NVM3_FLASH_PAGES=4; NVM3_DEFAULT_CACHE_SIZE=200; NVM3_MAX_OBJECT_SIZE=254; NVM3_DEFAULT_REPACK_HEADROOM=0; PHY_RAIL=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\v2.6; ..\..\v2.6\protocol\zigbee\app\framework; ..\..\v2.6\protocol\zigbee\app\framework\..\..; ..\..\v2.6\protocol\zigbee\app\framework\..\..\stack; ..\..\v2.6\protocol\zigbee\app\framework\..\util; ..\..\v2.6\protocol\zigbee\app\framework\include; ..\..\v2.6\platform\base\hal; ..\..\v2.6\platform\base\hal\plugin; ..\..\v2.6\platform\base\hal\..; ..\..\v2.6\platform\base\hal\micro\cortexm3\efm32; ..\..\v2.6\platform\base\hal\micro\cortexm3\efm32\config; ..\..\v2.6\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\v2.6\platform\base\hal\..\..\CMSIS\Include; ..\..\v2.6\platform\base\hal\..\..\Device\SiliconLabs\efr32mg21\Include; ..\..\v2.6\platform\base\hal\..\..\emdrv\common\inc; ..\..\v2.6\platform\base\hal\..\..\emdrv\config; ..\..\v2.6\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\v2.6\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\v2.6\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\v2.6\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\v2.6\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\v2.6\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\v2.6\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\v2.6\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\v2.6\platform\base\hal\..\..\emlib\inc; ..\..\v2.6\platform\base\hal\..\..\middleware\glib; ..\..\v2.6\platform\base\hal\..\..\middleware\glib\glib; ..\..\v2.6\platform\base\hal\..\..\radio\rail_lib\plugin; ..\..\v2.6\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\v2.6\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\v2.6\platform\halconfig\inc\hal-config; ..\..\v2.6\hardware\module\config; ..\..\v2.6\hardware\kit\common\halconfig; ..\..\v2.6\hardware\kit\common\bsp; hal-config; ..\..\v2.6\platform\bootloader; ..\..\v2.6\platform\emdrv\nvm3\inc; ..\..\v2.6\platform\radio\rail_lib\chip\efr32\efr32xg2x; ..\..\v2.6\platform\radio\rail_lib\common; ..\..\v2.6\platform\radio\rail_lib\plugin\coexistence\common; ..\..\v2.6\platform\radio\rail_lib\plugin\coexistence\hal\efr32; ..\..\v2.6\platform\radio\rail_lib\plugin\coexistence\protocol\ieee802154; ..\..\v2.6\platform\radio\rail_lib\protocol\ble; ..\..\v2.6\platform\radio\rail_lib\protocol\ieee802154; ..\..\v2.6\platform\radio\rail_lib\protocol\zwave; ..\..\v2.6\util\plugin\plugin-common\mbedtls; ..\..\v2.6\util\third_party\mbedtls; ..\..\v2.6\util\third_party\mbedtls\include; ..\..\v2.6\util\third_party\mbedtls\include\mbedtls; ..\..\v2.6\util\third_party\mbedtls\sl_crypto\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: LOCAL_STORAGE_BTL; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; EFR32_SERIES2_CONFIG1_MICRO; EFR32MG21; EFR32MG21A010F1024IM32; ATTRIBUTE_STORAGE_CONFIGURATION="z3_lite_timer_mg21_v660_endpoint_config.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="z3_lite_timer_mg21_v660_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="z3_lite_timer_mg21_v660.h"; PSSTORE_SIZE=0; LONGTOKEN_SIZE=0; LOCKBITS_IN_MAINFLASH_SIZE=8192; HAL_CONFIG=1; EMBER_AF_USE_HWCONF; LED_BLINK_PERIOD_MS=1000; NO_LED=1; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_STACK_ZIGBEE; MBEDTLS_CONFIG_FILE="mbedtls-config-generated.h"; USE_NVM3; NVM3_DEFAULT_NVM_SIZE=NVM3_FLASH_PAGES*FLASH_PAGE_SIZE; EMLIB_USER_CONFIG; HAL_BULBPWM_ENABLE=1; HAL_BULBPWM_FREQUENCY=1000; APPLICATION_TOKEN_HEADER="znet-token.h"; APPLICATION_MFG_TOKEN_HEADER="znet-mfg-token.h"; MBEDTLS_DEVICE_ACCELERATION_CONFIG_FILE="configs/config-device-acceleration.h"; MBEDTLS_DEVICE_ACCELERATION_CONFIG_APP_FILE="config-device-acceleration-app.h"; NVM3_FLASH_PAGES=4; NVM3_DEFAULT_CACHE_SIZE=200; NVM3_MAX_OBJECT_SIZE=254; NVM3_DEFAULT_REPACK_HEADROOM=0; PHY_RAIL=1
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\v2.6; ..\..\v2.6\protocol\zigbee\app\framework; ..\..\v2.6\protocol\zigbee\app\framework\..\..; ..\..\v2.6\protocol\zigbee\app\framework\..\..\stack; ..\..\v2.6\protocol\zigbee\app\framework\..\util; ..\..\v2.6\protocol\zigbee\app\framework\include; ..\..\v2.6\platform\base\hal; ..\..\v2.6\platform\base\hal\plugin; ..\..\v2.6\platform\base\hal\..; ..\..\v2.6\platform\base\hal\micro\cortexm3\efm32; ..\..\v2.6\platform\base\hal\micro\cortexm3\efm32\config; ..\..\v2.6\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\v2.6\platform\base\hal\..\..\CMSIS\Include; ..\..\v2.6\platform\base\hal\..\..\Device\SiliconLabs\efr32mg21\Include; ..\..\v2.6\platform\base\hal\..\..\emdrv\common\inc; ..\..\v2.6\platform\base\hal\..\..\emdrv\config; ..\..\v2.6\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\v2.6\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\v2.6\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\v2.6\platform\base\hal\..\..\emdrv\rtcdrv\test; ..\..\v2.6\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\v2.6\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\v2.6\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\v2.6\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\v2.6\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\v2.6\platform\base\hal\..\..\emlib\inc; ..\..\v2.6\platform\base\hal\..\..\middleware\glib; ..\..\v2.6\platform\base\hal\..\..\middleware\glib\glib; ..\..\v2.6\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\v2.6\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\v2.6\platform\halconfig\inc\hal-config; ..\..\v2.6\hardware\kit\common\halconfig; ..\..\v2.6\hardware\kit\common\bsp; hal-config; ..\..\v2.6\platform\bootloader; ..\..\v2.6\platform\emdrv\nvm3\inc; ..\..\v2.6\platform\radio\rail_lib\chip\efr32\efr32xg2x; ..\..\v2.6\platform\radio\rail_lib\common; ..\..\v2.6\platform\radio\rail_lib\plugin\coexistence\common; ..\..\v2.6\platform\radio\rail_lib\plugin\coexistence\hal\efr32; ..\..\v2.6\platform\radio\rail_lib\plugin\coexistence\protocol\ieee802154; ..\..\v2.6\platform\radio\rail_lib\protocol\ble; ..\..\v2.6\platform\radio\rail_lib\protocol\ieee802154; ..\..\v2.6\platform\radio\rail_lib\protocol\zwave; ..\..\v2.6\util\plugin\plugin-common\mbedtls; ..\..\v2.6\util\third_party\mbedtls; ..\..\v2.6\util\third_party\mbedtls\include; ..\..\v2.6\util\third_party\mbedtls\include\mbedtls; ..\..\v2.6\util\third_party\mbedtls\sl_crypto\include
  OBJCOPY.OOCOutputFile: z3_lite_timer_mg21_v660.s37
  prebuild: z3_lite_timer_mg21_v660-prebuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' 'C:\SiliconLabs\SimplicityStudio\v4'
  postbuild: z3_lite_timer_mg21_v660-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' 'C:\SiliconLabs\SimplicityStudio\v4'
  ILINK.IlinkOutputFile: z3_lite_timer_mg21_v660.out
  ILINK.IlinkConfigDefines: FLASH_SIZE=1048576; RAM_SIZE=98304; FLASH_PAGE_SIZE=8192; SIMEEPROM_SIZE=32768; PSSTORE_SIZE=0; LONGTOKEN_SIZE=0; LOCKBITS_IN_MAINFLASH_SIZE=8192; HEADER_SIZE=256; LOCAL_STORAGE_BTL=1; EMBER_MALLOC_HEAP_SIZE=0
  ILINK.IlinkIcfFile: ..\..\v2.6\platform\base\hal\micro\cortexm3\efm32\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../v2.6/platform/base/hal/plugin/adc/: adc-efr32.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/aes-cmac/: aes-cmac.c
    ../../v2.6/util/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../v2.6/util/third_party/mbedtls/sl_crypto/src/: aes_aes.c crypto_aes.c crypto_ble.c crypto_ecp.c crypto_management.c crypto_sha.c cryptoacc_aes.c cryptoacc_ccm.c cryptoacc_cmac.c cryptoacc_ecp.c cryptoacc_gcm.c cryptoacc_management.c cryptoacc_sha.c cryptoacc_trng.c entropy_adc.c entropy_rail.c radioaes.c radioaes_aes.c radioaes_ble.c se_aes.c se_ccm.c se_cmac.c se_ecp.c se_jpake.c se_management.c se_sha.c se_trng.c shax.c trng.c
    ../../v2.6/protocol/zigbee/app/framework/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c message.c multi-network.c print-formatter.c print.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c time-util.c util.c
    ../../v2.6/protocol/zigbee/app/framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ../../v2.6/platform/base/hal/plugin/antenna-stub/: antenna-stub.c
    ../../v2.6/platform/base/hal/micro/cortexm3/efm32/: assert-crash-handlers.c bootloader-interface-app.c bootloader-interface.c button.c cstartup-common.c diagnostic.c ext-device.c faults-v7m.s79 hal-config-gpio.c hal-config.c isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep-efm32.c token.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/basic/: basic.c
    ../../v2.6/platform/bootloader/api/: btl_interface.c btl_interface_storage.c
    ../../v2.6/platform/base/hal/plugin/buzzer/: buzzer-efr32.c
    ./: call-command-handler.c callback-stub.c stack-handler-stub.c z3_lite_timer_mg21_v660_callbacks.c znet-bookkeeping.c znet-cli.c
    ../../v2.6/protocol/zigbee/stack/framework/: ccm-star.c strong-random-api.c
    ../../v2.6/platform/radio/rail_lib/plugin/coexistence/protocol/ieee802154/: coexistence-802154.c coulomb-counter-802154.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/color-control-server/: color-control-server.c
    ../../v2.6/platform/base/hal/plugin/serial/cortexm/efm32/: com.c
    ../../v2.6/protocol/zigbee/app/util/serial/: command-interpreter2.c
    ../../v2.6/protocol/zigbee/app/framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/counters/: counters-cli.c counters-ota.c counters-soc.c
    ../../v2.6/platform/base/hal/micro/generic/: crc.c endian.c mem-util.c random.c token-def.c
    ../../v2.6/platform/base/hal/plugin/debug-jtag/: debug-jtag-efr32.c
    ../../v2.6/platform/base/hal/: ember-base-configuration.c
    ../../v2.6/protocol/zigbee/stack/config/: ember-configuration.c
    ../../v2.6/platform/base/hal/plugin/serial/: ember-printf.c serial.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/find-and-bind-target/: find-and-bind-target-cli.c find-and-bind-target.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/green-power-client/: green-power-client-cli.c green-power-client.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/green-power-common/: green-power-common.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/groups-server/: groups-server-cli.c groups-server.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/heartbeat/: heartbeat.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/identify/: identify-cli.c identify.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/interpan/: interpan-cli.c interpan-soc.c interpan.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/level-control/: level-control.c
    ../../v2.6/protocol/zigbee/app/util/common/: library.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/network-creator/: network-creator-cli.c network-creator.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/network-creator-security/: network-creator-security-cli.c network-creator-security.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/network-steering/: network-steering-cli.c network-steering-soc.c network-steering-v2.c network-steering.c
    ../../v2.6/platform/emdrv/nvm3/src/: nvm3_default.c nvm3_hal_flash.c nvm3_lock.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/on-off/: on-off.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/reporting/: reporting-cli.c reporting-default-configuration.c reporting.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/scan-dispatch/: scan-dispatch.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/scenes/: scenes-cli.c scenes.c
    ../../v2.6/protocol/zigbee/app/util/security/: security-address-cache.c
    ../../v2.6/platform/base/hal/plugin/debug/rtt/: SEGGER_RTT.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/simple-main/: simple-main.c
    ../../v2.6/platform/emdrv/uartdrv/src/: uartdrv.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/update-tc-link-key/: update-tc-link-key-cli.c update-tc-link-key.c
    ../../v2.6/protocol/zigbee/app/util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/zll-commissioning-common/: zll-commissioning-cli.c zll-commissioning-common.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/zll-commissioning-server/: zll-commissioning-server.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/zll-identify-server/: zll-identify-server.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/zll-level-control-server/: zll-level-control-server.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/zll-on-off-server/: zll-on-off-server.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/zll-scenes-server/: zll-scenes-server.c
    ../../v2.6/protocol/zigbee/app/framework/plugin/zll-utility-server/: zll-utility-server.c
  group emdrv
    ../../v2.6/platform/emdrv/dmadrv/src/: dmadrv.c
    ../../v2.6/platform/emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../v2.6/platform/emdrv/rtcdrv/src/: rtcdriver.c
    ../../v2.6/platform/emdrv/sleep/src/: sleep.c
    ../../v2.6/platform/emdrv/tempdrv/src/: tempdrv.c
    ../../v2.6/platform/emdrv/ustimer/src/: ustimer.c
  group emlib
    ../../v2.6/platform/emlib/src/: em_adc.c em_cmu.c em_core.c em_cryotimer.c em_emu.c em_gpio.c em_i2c.c em_ldma.c em_leuart.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_se.c em_system.c em_timer.c em_usart.c em_wdog.c
    ../../v2.6/platform/Device/SiliconLabs/EFR32MG21/Source/: system_efr32mg21.c
  group Libraries
    ../../v2.6/protocol/zigbee/build/binding-table-library-cortexm3-iar-efr32mg21-rail/: binding-table-library.a
    ../../v2.6/protocol/zigbee/build/cbke-163k1-stub-library-cortexm3-iar-efr32mg21-rail/: cbke-163k1-stub-library.a
    ../../v2.6/protocol/zigbee/build/cbke-283k1-stub-library-cortexm3-iar-efr32mg21-rail/: cbke-283k1-stub-library.a
    ../../v2.6/protocol/zigbee/build/cbke-library-dsa-sign-stub-cortexm3-iar-efr32mg21-rail/: cbke-library-dsa-sign-stub.a
    ../../v2.6/protocol/zigbee/build/cbke-library-dsa-verify-283k1-stub-cortexm3-iar-efr32mg21-rail/: cbke-library-dsa-verify-283k1-stub.a
    ../../v2.6/protocol/zigbee/build/cbke-library-dsa-verify-stub-cortexm3-iar-efr32mg21-rail/: cbke-library-dsa-verify-stub.a
    ../../v2.6/protocol/zigbee/build/cbke-stub-library-cortexm3-iar-efr32mg21-rail/: cbke-stub-library.a
    ../../v2.6/protocol/zigbee/build/debug-basic-library-cortexm3-iar-efr32mg21-rail/: debug-basic-library.a
    ../../v2.6/protocol/zigbee/build/debug-extended-stub-library-cortexm3-iar-efr32mg21-rail/: debug-extended-stub-library.a
    ../../v2.6/protocol/zigbee/build/end-device-bind-stub-library-cortexm3-iar-efr32mg21-rail/: end-device-bind-stub-library.a
    ../../v2.6/protocol/zigbee/build/gp-library-cortexm3-iar-efr32mg21-rail/: gp-library.a
    ../../v2.6/protocol/zigbee/build/hal-library-cortexm3-iar-efr32mg21-rail/: hal-library.a
    ../../v2.6/protocol/zigbee/build/install-code-library-cortexm3-iar-efr32mg21-rail/: install-code-library.a
    ../../v2.6/platform/emdrv/nvm3/lib/: libnvm3_CM33_iar.a
    ../../v2.6/platform/radio/rail_lib/autogen/librail_release/: librail_efr32xg21_iar_release.a
    ../../v2.6/protocol/zigbee/build/multi-network-stub-library-cortexm3-iar-efr32mg21-rail/: multi-network-stub-library.a
    ../../v2.6/protocol/zigbee/build/packet-validate-stub-library-cortexm3-iar-efr32mg21-rail/: packet-validate-stub-library.a
    ../../v2.6/protocol/zigbee/build/security-library-core-cortexm3-iar-efr32mg21-rail/: security-library-core.a
    ../../v2.6/protocol/zigbee/build/security-library-link-keys-stub-cortexm3-iar-efr32mg21-rail/: security-library-link-keys-stub.a
    ../../v2.6/protocol/zigbee/build/sim-eeprom2-to-nvm3-upgrade-stub-library-cortexm3-iar-efr32mg21-rail/: sim-eeprom2-to-nvm3-upgrade-stub-library.a
    ../../v2.6/protocol/zigbee/build/zigbee-pro-stack-cortexm3-iar-efr32mg21-rail/: zigbee-pro-stack.a
    ../../v2.6/protocol/zigbee/build/zigbee-r22-support-stub-library-cortexm3-iar-efr32mg21-rail/: zigbee-r22-support-stub-library.a
    ../../v2.6/protocol/zigbee/build/zll-library-cortexm3-iar-efr32mg21-rail/: zll-library.a
